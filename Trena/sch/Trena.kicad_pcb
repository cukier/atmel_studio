# Repository cukier/atmel_studio

## KiCad design Trena/sch/Trena.kicad_pcb

Board: 2 copper layers, 47.0 x 47.0 mm, 54 parts (0 on the bottom side), 34 nets.

Parts:
C1, C3, C4, C7, C8, C10: 100n; c_0805
C2, C5: 22p; c_0805
C6: 470uF; CP_8x11.5mm
C9: 470uF; CP_5x7mm
D1: D_ALT; do219ab
D2, D9, D10: LED VERDE; LED_0805
D3, D4, D8: LED VERMELHO; LED_0805
D5: PWR; Led_0805
D6: RX; Led_0805
D7: TX; Led_0805
F1: Polyfuse; r_1210
J1: ICSP; pin_strip_3x2
J5: HC-SR04; pin_socket_4
J6: RJ45; rj45-shield
Q1: PN2222A; sot23
Q2, Q3, Q4, Q5: BC817-40; sot23
R1, R2, R4, R6, R9, R11, R15, R17: 10k; r_0805
R3, R5, R7, R8, R16, R21: 1k; r_0805
R10, R12, R18, R19: 560R; r_0805
R13, R14: 360R; r_0805
R20: 120R; r_0805
U1: ATMEGA328P-AU; lqfp32
U2: LM1117-5.0; sot223
U3: SP3485CN; so-8
Y1: Crystal; crystal_hc-49%2fsmd

Connections:
+5V: C1.1, C3.1, C4.1, C8.1, C9.1, C10.1, D2.2, D3.2, D4.2, D5.2, D8.2, D9.2, D10.2, J1.2, J5.1, R1.1, R2.1, R4.1, R6.2, R9.1, R10.2, R11.1, R12.1, R15.1, R17.1, R18.2, U1.4, U1.6, U1.18, U2.2, U2.4, U3.8
/A: J6.4, R18.1, R20.2, U3.6
/B: J6.5, R19.2, R20.1, U3.7
/INT1: R8.2, U1.12
/INT2: Q3.2, R15.2, U1.13
/LED1: R21.1, U1.23
/LED2: R3.1, U1.24
/MISO: J1.1, U1.16
/MOSI: J1.4, U1.15
/PIN: F1.2, J6.2
/RESET: J1.5, R1.2, U1.29
/RX: R13.2, U1.30
/SCK: J1.3, U1.17
/TX: D7.1, R6.1, R7.1, R14.2, U1.31
/XTAL1: C2.1, U1.7, Y1.1
/XTAL2: C5.1, U1.8, Y1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.6, J5.4, J6.1, Q1.3, Q2.3, Q3.3, Q4.3, Q5.3, R5.1, R19.1, U1.3, U1.5, U1.21, U2.1, U3.5
unnamed: C6.1, C7.1, D1.1, U2.3
unnamed: D1.2, F1.1
unnamed: D3.1, D4.1, D8.1, Q4.2, R4.2
unnamed: D5.1, R5.2
unnamed: D6.1, R13.1, R17.2, U3.1
unnamed: D6.2, R10.1
unnamed: D7.2, R12.2
unnamed: D2.1, D9.1, D10.1, Q5.2, R2.2
unnamed: J5.3, R16.2
unnamed: J5.2, Q2.2, R11.2
unnamed: Q1.1, R7.2
unnamed: Q1.2, R9.2, U3.2, U3.3
unnamed: Q2.1, R8.1
unnamed: Q3.1, R16.1
unnamed: Q4.1, R3.2
unnamed: Q5.1, R21.2
unnamed: R14.1, U3.4

## KiCad design ReleModbus/sch/ReleModbus.kicad_pcb

Parts:
C1, C3, C7, C8, C11: 100nF; c_0805
C2, C4: 22pF; c_0805
C6: 470uF 35V; CP_8x7mm
C9: 470uF 25V; CP_6.3x11mm
C10, C12, C13, C14: 10uF 10V; CP_4x5mm
D1, D2, D3: D_ALT; do219ab
D4: RX; Led_0805
D5: TX; Led_0805
D6: PWR; Led_0805
J1: PWR; mkds_1,5-2
J2: ICSP; pin_strip_3x2
J3: I2C; pin_socket_2
J4: DB9_FEMALE; DB_9F
J5: COMUM; mkds_1,5-2
J6: N_ABERTO; mkds_1,5-2
J7: N_FECHADO; mkds_1,5-2
Q1, Q2: BC817; sot23
R1, R2: 4k7; r_0805
R3, R4: 1k; r_0805
R5, R6, R9: 10k; r_0805
R7, R8: 330R; r_0805
R10, R11, R12: 560R; r_0805
RLY1, RLY2: RELAY_HJR-3FF_Z; relay_hjr-3ff_z
RV1: 30V; BOURNS-MOV-14DxxxK_THRU-VARISTOR
U1: ATMEGA328P-AU; lqfp32
U2: LM7805CT; to220-horiz_5770
U3: MAX232; so-16
Y1: 16MHz; crystal_hc-49%2fsmd

Connections:
+5V: C1.1, C3.1, C8.1, C9.1, C11.1, D2.2 (K), D3.2 (K), R1.1, R2.1, R5.2, R6.2, R9.2, R12.2, RLY1.5, RLY2.5, U1.7, U1.20, U2.3 (OUT), U3.16 (VCC)
/C1: J5.1, RLY1.1
/C2: J5.2, RLY2.1
/MISO: J2.1, U1.18
/MOSI: J2.4, U1.17
/NA1: J6.1, RLY1.3
/NA2: J6.2, RLY2.3
/NF1: J7.1, RLY1.4
/NF2: J7.2, RLY2.4
/RST: J2.5, R9.1, U1.1
/RX: J4.2, R11.2, U3.8 (R2IN)
/RX_TTL: R7.2, U1.2
/R_EN: R3.2, R4.2, U1.25
/SCK: J2.3, U1.19
/SCL: J3.2, R2.2, U1.28
/SDA: J3.1, R1.2, U1.27
/TX: J4.3, R10.2, U3.7 (T2OUT)
/TX_TTL: R8.2, U1.3
/XTAL1: C4.1, U1.9, Y1.2
/XTAL2: C2.1, U1.10, Y1.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C11.2, C13.2, C14.1, D4.1 (K), D5.1 (K), D6.1 (K), J1.2, J2.6, J4.5, Q1.3 (E), Q2.3 (E), RV1.2, U1.8, U1.22, U2.2 (GND), U3.15 (GND)
unnamed: C6.1, C7.1, D1.2 (K), U2.1 (IN)
unnamed: C10.1, U3.1 (C1+)
unnamed: C10.2, U3.3 (C1-)
unnamed: C12.1, U3.4 (C2+)
unnamed: C12.2, U3.5 (C2-)
unnamed: C13.1, U3.2 (VS+)
unnamed: C14.2, U3.6 (VS-)
unnamed: D1.1 (A), J1.1, RV1.1
unnamed: D2.1 (A), Q1.2 (C), R5.1, RLY1.2
unnamed: D3.1 (A), Q2.2 (C), R6.1, RLY2.2
unnamed: D4.2 (A), R10.1
unnamed: D5.2 (A), R11.1
unnamed: D6.2 (A), R12.1
unnamed: J4.7, J4.8
unnamed: Q1.1 (B), R3.1
unnamed: Q2.1 (B), R4.1
unnamed: R7.1, U3.10 (T2IN)
unnamed: R8.1, U3.9 (R2OUT)

Board: 2 copper layers, 66.0 x 77.0 mm, 51 parts (8 on the bottom side), 39 nets.

Other parts of the board:
hole_3mm, hole_3mm#2, hole_3mm#3, hole_3mm#4: VAL**; hole_3mm

## KiCad design MultiplexadorSerial/sch/MultiplexadorSerial.kicad_pcb

Board: 2 copper layers, 69.2 x 53.9 mm, 68 parts (0 on the bottom side), 45 nets.

Parts:
C1, C2, C3, C4, C5: 100nF; c_0805
D1: RX; Led_0805
D2: TX; Led_0805
D3: PWR; Led_0805
J1: SL1; pin_socket_2
J2: SL3; pin_socket_2
J3: SL4; pin_socket_2
J4: SL2; pin_socket_2
J5: SL; pin_socket_3
Q1, Q2, Q3, Q4: Q_NPN_CBE; sot23
R1, R2, R5, R6, R7, R8, R11, R12, R19, R21, R22, R23, R26, R27, R28, R30, R39, R40: 10k; r_0805
R3, R4, R9, R10, R20, R24, R25, R29: 360R; r_0805
R13, R15, R31, R34: 120R; r_0805
R14, R16, R17, R18, R32, R33, R35, R36, R44: 560R; r_0805
R37, R38, R41, R42: 330R; r_0805
R43, R45: 1k2; r_0805
SHIELD1: ARDUINO_SHIELD; ARDUINO SHIELD
U1, U2, U3, U4: SP3481CP; so-8
U5: 4052; so-16

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, D3.1, R5.2, R6.2, R7.1, R8.1, R11.1, R12.1, R17.1, R18.1, R21.2, R23.1, R26.1, R27.2, R28.1, R30.1, R33.1, R36.1, R43.1, R44.1, SHIELD1.5V, U1.8, U2.8, U3.8, U4.8, U5.16
/ADR0: R37.1, SHIELD1.AD0
/ADR1: R38.1, SHIELD1.AD1
/RX: J5.1, R42.1, SHIELD1.0
/RX1: R1.2, R3.1, U5.1
/RX2: R22.2, R25.1, U5.5
/RX3: R2.2, R4.1, U5.2
/RX4: R19.2, R20.1, U5.4
/TX: D2.2, J5.2, R41.1, SHIELD1.1
/TX1: R5.1, R9.1, U5.12
/TX2: R27.1, R29.1, U5.14
/TX3: R6.1, R10.1, U5.15
/TX4: R21.1, R24.1, U5.11
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J5.3, Q1.1, Q2.1, Q3.1, Q4.1, R14.2, R16.2, R32.2, R35.2, R39.1, R40.1, R45.1, SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, U1.5, U2.5, U3.5, U4.5, U5.6, U5.7, U5.8
unnamed: D1.1, R44.2
unnamed: D1.2, R42.2, U5.3
unnamed: D2.1, R43.2
unnamed: D3.2, R45.2
unnamed: J1.1, R13.1, R17.2, U1.6
unnamed: J1.2, R13.2, R14.1, U1.7
unnamed: J2.1, R15.1, R18.2, U2.6
unnamed: J2.2, R15.2, R16.1, U2.7
unnamed: J3.1, R31.1, R33.2, U3.6
unnamed: J3.2, R31.2, R32.1, U3.7
unnamed: J4.1, R34.1, R36.2, U4.6
unnamed: J4.2, R34.2, R35.1, U4.7
unnamed: Q1.2, R1.1
unnamed: Q1.3, R7.2, U1.2, U1.3
unnamed: Q2.2, R2.1
unnamed: Q2.3, R8.2, U2.2, U2.3
unnamed: Q3.2, R19.1
unnamed: Q3.3, R23.2, U3.2, U3.3
unnamed: Q4.2, R22.1
unnamed: Q4.3, R28.2, U4.2, U4.3
unnamed: R9.2, U1.4
unnamed: R10.2, U2.4
unnamed: R3.2, R11.2, U1.1
unnamed: R4.2, R12.2, U2.1
unnamed: R20.2, R26.2, U3.1
unnamed: R24.2, U3.4
unnamed: R25.2, R30.2, U4.1
unnamed: R29.2, U4.4
unnamed: R37.2, R39.2, U5.10
unnamed: R38.2, R40.2, U5.9
unnamed: R41.2, U5.13

## Commit log

2017-04-03 i2c para avr
2017-04-03 simulacao
2017-04-04 calendario DS1307
2017-04-04 Calendario
2017-04-10 i2c eeprom ok
2017-04-10 DS1307 ok
2017-04-10 eeprom 16bits
2017-04-10 eeprom_read_word
2017-04-10 Modbus ok
2017-04-12 fazendo registro teste
2017-04-12 analogico
2017-04-23 lcd_printf
2017-08-03 https://github.com/andygock/avr-uart
2017-08-03 uart_printf fix
2017-08-03 avr-can-libc
2017-08-09 uart
2017-09-05 respondendo mem interna Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-09-12 mem eeprom
2017-09-12 eprom interna
2017-09-13 mem Signed-off-by: cuki <mauriciocukier@gmail.com>
2017-09-13 sync modbus
2017-09-29 Mulx Demux para serial
2017-09-29 modbus not ok Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-10-02 sim blink
2017-10-02 modbus multiplex
2017-10-02 2560
2017-10-02 2 uart 2560
2017-10-02 mestre modbus
2017-10-02 uart echo
2017-10-06 Disparando 32 posicoes
2017-10-06 modbus multiplexado
2017-10-10 disparos
2017-10-10 Disparo a cada 2s Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-10-12 Arduino
2017-10-12 Disparador para arduino
2017-10-15 V2 Disparador
2017-10-18 V 3 Disparador Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-10-23 Versao 4 do disparador
2017-10-26 Placa Multiplexador Serial
2017-10-26 Posicionamento MultiplexadorSerial Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-10-27 Multiplexador Serial RS485 arduino
2017-10-27 Bottom
2017-10-27 Timer Arduino
2017-10-27 1ms ok
2017-10-27 Disparador 60s ok
2017-11-06 V4.2 Disparador
2017-11-06 Multiplexador Serial
2017-11-06 Recebendo
2017-11-07 Trilas
2017-11-07 escutando 4 portas
2017-11-08 fun5 Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-11-09 fun4 ok fun6 ok
2017-11-09 Uart 2 Nao ok
2017-11-10 nova uart
2017-11-10 uart_done
2017-11-15 Tentative de um timer em OO
2017-11-16 TimerCpp
2017-11-16 adicionado resistores pull ups nos transdutores
2017-11-17 fun8 Recebe de 2 mestres e passa a informacao ao escravo
2017-11-17 placa em smd
2017-11-17 posicionamento smd
2017-11-27 fun 8_2
2017-11-28 novo desenho
2017-11-28 UartCpp imprimindo
2017-11-28 Transdutor
2017-11-28 UartCpp namespace
2017-11-29 nova uart em modbus
2017-11-29 led bicolor com timer0
2017-11-29 teste de echo
2017-11-29 put_s
2017-11-29 Controlador
2017-11-29 19200 8n1 Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-11-29 mudanca por int tempo
2017-11-30 controle da porta via interrupcao de tempo
2017-12-01 uart cpp template errado
2017-12-05 double printf
2017-12-05 UartCpp lib
2017-12-05 ReleModbus
2017-12-06 placa relemodbus
2017-12-07 UartCpp Signed-off-by: cuki2 <mauricio@krebs.com.br>
2017-12-19 Trena Serial
2017-12-20 Trilhas Trena Serial
2018-01-31 Trena Rev 1
2018-02-02 Rev 2 Trena
2018-02-05 Trena Posicionamento REV 3
2018-02-09 Trema Rev 3
2018-02-18 trena trafo ee16 lnk364pn
2018-03-02 BOM Trena
2018-03-02 Gerber Rele Modbus R0
2018-04-30 timers
2018-05-25 percentimetro modbus necessario refazer timer1
2018-05-25 correcao percentimetro
2018-06-13 Projeto lixo
2018-06-18 i2c master i2c slave
2018-06-18 i2c slave
2018-06-26 AVRI2C
